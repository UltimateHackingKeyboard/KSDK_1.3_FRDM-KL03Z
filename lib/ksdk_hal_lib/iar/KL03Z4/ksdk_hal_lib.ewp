# IAR project ksdk_hal_lib.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: MKL03Z32xxx4 Freescale MKL03Z32xxx4
  ICCARM.CCDefines: DEBUG; CPU_MKL03Z32VFK4
  ICCARM.CCDiagSuppress: Pa039,Pe068,Pe069,Pa082,Pe177,Pe186,Pe550,Pa050
  ICCARM.CCIncludePath2: ../../../../platform/CMSIS/Include; ../../../../platform/devices; ../../../../platform/devices/MKL03Z4/include; ../../../../platform/devices/MKL03Z4/startup; ../../../../platform/utilities/inc; ../../../../platform/hal/inc
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 2
  AARM.ADefines: DEBUG
  ILINK.IlinkOutputFile: psp_arm.out
configuration Release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NDEBUG; CPU_MKL03Z32VFK4
  ICCARM.CCOptLevel: 3
  ILINK.IlinkOutputFile: libgeneric.out
  group platform/hal/adc16
    ../../../../platform/hal/src/adc16/: fsl_adc16_hal.c
    ../../../../platform/hal/inc/: fsl_adc16_hal.h
  group platform/hal/cmp
    ../../../../platform/hal/src/cmp/: fsl_cmp_hal.c
    ../../../../platform/hal/inc/: fsl_cmp_hal.h
  group platform/hal/cop
    ../../../../platform/hal/src/cop/: fsl_cop_hal.c
    ../../../../platform/hal/inc/: fsl_cop_hal.h
  group platform/hal/gpio
    ../../../../platform/hal/src/gpio/: fsl_gpio_hal.c
    ../../../../platform/hal/inc/: fsl_gpio_hal.h
  group platform/hal/i2c
    ../../../../platform/hal/src/i2c/: fsl_i2c_hal.c
    ../../../../platform/hal/inc/: fsl_i2c_hal.h
  group platform/hal/llwu
    ../../../../platform/hal/src/llwu/: fsl_llwu_hal.c
    ../../../../platform/hal/inc/: fsl_llwu_hal.h
  group platform/hal/lptmr
    ../../../../platform/hal/src/lptmr/: fsl_lptmr_hal.c
    ../../../../platform/hal/inc/: fsl_lptmr_hal.h
  group platform/hal/mcglite
    ../../../../platform/hal/src/mcglite/: fsl_mcglite_hal.c fsl_mcglite_hal_modes.c
    ../../../../platform/hal/inc/: fsl_mcglite_hal.h fsl_mcglite_hal_modes.h
  group platform/hal/osc
    ../../../../platform/hal/src/osc/: fsl_osc_hal.c
    ../../../../platform/hal/inc/: fsl_osc_hal.h
  group platform/hal/port
    ../../../../platform/hal/src/port/: fsl_port_hal.c
    ../../../../platform/hal/inc/: fsl_port_hal.h
  group platform/hal/rcm
    ../../../../platform/hal/src/rcm/: fsl_rcm_hal.c
    ../../../../platform/hal/inc/: fsl_rcm_hal.h
  group platform/hal/rtc
    ../../../../platform/hal/src/rtc/: fsl_rtc_hal.c
    ../../../../platform/hal/inc/: fsl_rtc_hal.h
  group platform/hal/sim
    ../../../../platform/hal/inc/: fsl_sim_hal.h
  group platform/hal/sim/system
    ../../../../platform/hal/src/sim/MKL03Z4/: fsl_sim_hal_MKL03Z4.c fsl_sim_hal_MKL03Z4.h
  group platform/hal/smc
    ../../../../platform/hal/src/smc/: fsl_smc_hal.c
    ../../../../platform/hal/inc/: fsl_smc_hal.h
  group platform/hal/spi
    ../../../../platform/hal/src/spi/: fsl_spi_hal.c
    ../../../../platform/hal/inc/: fsl_spi_hal.h
  group platform/hal/tpm
    ../../../../platform/hal/inc/: fsl_tpm_hal.h
    ../../../../platform/hal/src/tpm/: fsl_tpm_hal.c
  group platform/hal/lpuart
    ../../../../platform/hal/src/lpuart/: fsl_lpuart_hal.c
    ../../../../platform/hal/inc/: fsl_lpuart_hal.h
  group platform/hal/pmc
    ../../../../platform/hal/inc/: fsl_pmc_hal.h
  group platform/hal/vref
    ../../../../platform/hal/src/vref/: fsl_vref_hal.c
    ../../../../platform/hal/inc/: fsl_vref_hal.h
